# Keil uVision project RFFC.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: RFFC.axf +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\driver;.\F33x;.\RFFC
  group RFFC2071
    ./RFFC/: RFFC2071.c PLL_ControlInterface.c
  group Driver
    ./driver/: init.c STARTUP.A51
  group F33X
    ./F33x/: F330_FlashPrimitives.c F330_FlashUtils.c
  group User
    ./USER/: main.c para.c C8051F330.txt serial.c
